# Keil uVision project temperature_control_blender_hal.uvprojx, settings and files
target temperature_control_blender_hal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: temperature_control_blender_hal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,COM_DEBUG_ENABLE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./User/App;./User/Com;./User/Dri;./User/Int;./User/Mid;./User/Mid/FreeRTOS;./User/Mid/FreeRTOS/src;./User/Mid/FreeRTOS/port;./User/Mid/FreeRTOS/inc;./User/Mid/free_modbus/modbus/include;./User/Mid/free_modbus/modbus/rtu;./User/Mid/free_modbus/port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: can.c main.c gpio.c adc.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_can.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ./User/App/: App_buzzer.c App_buzzer.h App_main.c App_main.h App_system.c App_system.h App_storage.c App_storage.h App_oled.c App_oled.h App_key.c App_key.h App_ui.c App_ui.h App_motor.c App_motor.h App_heater.c App_heater.h App_rtc.c App_rtc.h App_bluetooth.c App_bluetooth.h App_imu.c App_imu.h App_protocol.c App_protocol.h App_can.c App_can.h App_modbus.c App_modbus.h
  group Com
    ./User/Com/: Com_debug.c Com_debug.h
  group Int
    ./User/Int/: bsp_pins.h Int_I2C2.c Int_I2C2.h Int_I2C1.c Int_I2C1.h Int_SPI2.c Int_SPI2.h Int_Bluetooth.c Int_Bluetooth.h
  group Mid
    ./User/Mid/free_modbus/modbus/: mb.c
    ./User/Mid/free_modbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncfile.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./User/Mid/free_modbus/modbus/rtu/: mbcrc.c mbrtu.c mbcrc.h mbrtu.h
    ./User/Mid/free_modbus/port/: portevent.c portserial.c porttimer.c port.h app_freemodbus_port.h
    ./User/Mid/free_modbus/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group Dri
    ./User/Dri/: drv_m24c02.c drv_m24c02.h driver_ssd1315.c driver_ssd1315.h driver_ssd1315_font.h Dri_key.c Dri_key.h Dri_adc.c Dri_adc.h Dri_ds3231.c Dri_ds3231.h
  group FreeRTOS
    ./User/Mid/FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/inc
    ./User/Mid/FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/src
    ./User/Mid/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ./User/Mid/FreeRTOS/port/: heap_4.c port.c portmacro.h
software components: CMSIS:CORE 4.3.0
